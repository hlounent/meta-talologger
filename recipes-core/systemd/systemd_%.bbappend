PACKAGECONFIG_append = " networkd resolved timesyncd"
